# Keil uVision project template.uvprojx, settings and files
target N32WB03x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x1000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: template_repo
  AfterMake: fromelf --bin --output=.\bin\template_repo.bin .\Objects\template_repo.axf
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\module;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\firmware\CMSIS\core;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\firmware\CMSIS\device;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\firmware\n32wb03x_std_periph_driver\inc;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\src;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\rdts;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtss\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\inc;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gap;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llc;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\lld;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llm;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\arch;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\src;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\stack_common;..\inc\rw;..\inc\app_profile;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\arch;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\adv;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\timer;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\log;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\delay;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\sleep;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\sec
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\symdef\symbol_g15.obj
  group STARTUP
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/firmware/CMSIS/device/startup/: startup_n32wb03x.s
  group CMSIS
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/firmware/CMSIS/device/: system_n32wb03x.c
  group FWLB
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/firmware/n32wb03x_std_periph_driver/src/: misc.c n32wb03x_adc.c n32wb03x_crc.c n32wb03x_dma.c n32wb03x_exti.c n32wb03x_gpio.c n32wb03x_rcc.c n32wb03x_tim.c n32wb03x_usart.c n32wb03x_spi.c n32wb03x_lpuart.c n32wb03x_qflash.c n32wb03x_rtc.c
  group BLE_STACK
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_ble_stack/ip/ble/hl/src/att/: lib_att.c
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_ble_stack/stack_common/: rwip.c rwip_driver.c
  group BLE_PROFILE
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/: prf.c prf_utils.c
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/dis/diss/src/: diss.c diss_task.c
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/bas/bass/src/: bass.c bass_task.c
    ../src/app_profile/: custom_srv_common.c custom_srv.c custom_srv_task.c
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_ble_profile/ns_ius/ns_iuss/src/: ns_iuss.c ns_iuss_task.c
  group NS_DFU
    ../../../dfu/common/: dfu_crc.c dfu_delay.c dfu_led.c
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_library/dfu/: ns_dfu_ble.c ns_dfu_boot.c
  group Crypto
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_library/ecc/: ns_ecc.c sha256.c uECC.c
  group NS_LIB
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_library/log/: ns_log_lpuart.c ns_log_usart.c
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_library/sleep/: ns_sleep.c
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_library/error/: ns_error.c
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_library/timer/: ns_timer.c
    G:/_business/_n32wb_SDK/N32WB03x_SDK_V1.0.0/middlewares/Nationstech/ble_library/ns_library/sec/: ns_sec.c
  group BLE_APP
    ../src/: app.c app_task.c app_bond_handlers.c app_fsm.c app_sec_handlers.c
    ../src/app_profile/: app_dis.c app_batt.c app_custom_srv.c app_ns_ius.c
  group USER
    ../src/: main.c
  group MODULE
    ../module/: uevent.c platform.c scheduler.c timedate.c
  group CONFIG
    ../inc/: app_user_config.h app_user_callback_config.h
  group DOC
    ../: readme.txt
  group CONFIG
    ../inc/: app_user_config.h app_user_callback_config.h
  group DOC
    ../: readme.txt
target OTA_IMG_1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.0.0
  cpu: as above
  output: template_repo_ota1
  AfterMake: fromelf --bin --output=.\bin\template_repo_ota1.bin .\Objects\template_repo_ota1.axf
  AfterMake: cmd.exe /C copy .\bin\template_repo_ota1.bin G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\utilities\dfu\Image\APP1.bin
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER, APPLICATION, BLE_OTA_ENABLE
  c include: ..\inc;..\module;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\firmware\CMSIS\core;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\firmware\CMSIS\device;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\firmware\n32wb03x_std_periph_driver\inc;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\dis\diss\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\bas\bass\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\hogp\hogpd\src;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\rdts;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\rdts\rdtss\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_profile\ns_ius\ns_iuss\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ahi\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\inc;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gap;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\gatt;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\hl\src\l2c;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llc;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\lld;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\ble\ll\src\llm;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\em\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\hci\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\ip\sch\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\aes\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\dbg\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ecc_p256\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\h4tl\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\ke\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\rwip\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\rfinit\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\arch;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\api;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\modules\common\src;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\stack_common;..\inc\rw;..\inc\app_profile;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_ble_stack\arch;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\adv;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\timer;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\log;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\delay;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\sleep;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\error;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\ecc;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\dfu;G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\middlewares\Nationstech\ble_library\ns_library\sec;..\..\..\dfu\common
  library: MicroLIB
  memory RVCT4: ROM 0x1004000 size 0x1c000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: as above
target OTA_IMG_2 (ARM-ADS)
  device: N32WB031 Nationstech
  pack: Nationstech.N32WB03X_DFP.1.0.0
  cpu: as above
  output: template_repo_ota2
  AfterMake: fromelf --bin --output=.\bin\template_repo_ota2.bin .\Objects\template_repo_ota2.axf
  AfterMake: cmd.exe /C copy .\bin\template_repo_ota2.bin G:\_business\_n32wb_SDK\N32WB03x_SDK_V1.0.0\utilities\dfu\Image\APP2.bin
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: N32WB03X, USE_STDPERIPH_DRIVER, APPLICATION, BLE_OTA_ENABLE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1020000 size 0x1c000
  memory RVCT9: RAM 0x20004000 size 0x8000
  link misc: as above
